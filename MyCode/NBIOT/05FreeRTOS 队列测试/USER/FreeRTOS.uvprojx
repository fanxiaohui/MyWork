# Keil uVision project FreeRTOS.uvprojx, settings and files
target FreeRTOS (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: LED +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\USER;..\CORE;..\STM32F10x_FWLib\inc;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\HARDWARE\LED;..\FreeROTS\include;..\FreeROTS\portable\RVDS\ARM_CM3;..\HARDWARE\KEY;..\HARDWARE\EXIT;..\FreeROTS\include;..\HARDWARE\LED;..\HARDWARE\LCD;..\HARDWARE\TIME;..\HARDWARE\IIC;..\Driver;..\Driver\EXIT;..\Driver\IIC;..\Driver\KEY;..\Driver\LCD;..\Driver\LED;..\Driver\TIME
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group Driver
    ../Driver/EXIT/: EXIT.C
    ../Driver/IIC/: IIC.C
    ../Driver/KEY/: KEY.C
    ../Driver/LCD/: LCD.C
    ../Driver/LED/: led.c
    ../Driver/TIME/: TIME.C
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLIB
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_gpio.c stm32f10x_dbgmcu.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_exti.c stm32f10x_fsmc.c stm32f10x_tim.c
  group FreeRTOS_CORE
    ../FreeROTS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group FreeRTOS_PORTABLE
    ../FreeROTS/portable/MemMang/: heap_4.c
    ../FreeROTS/portable/RVDS/ARM_CM3/: port.c
  group DOC
    ../: README.TXT
